Commit message: code

File: assets/rickshaw/rickshaw.urdf (robot description, URDF)
Before this commit: robot rickshaw, 5 links, 4 joints
Links:
- link base_link: mass 36.0 -> 31.0
